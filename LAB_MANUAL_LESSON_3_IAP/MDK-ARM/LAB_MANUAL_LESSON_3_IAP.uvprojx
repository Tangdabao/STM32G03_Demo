# Keil uVision project LAB_MANUAL_LESSON_3_IAP.uvprojx, settings and files
target LAB_MANUAL_LESSON_3_IAP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G031K8Tx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: LAB_MANUAL_LESSON_3_IAP +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32G031xx,USE_HAL_DRIVER,STM32G031xx
  c include: ../Core/Inc; C:/Users/TANG/STM32Cube/Repository/STM32Cube_FW_G0_V1.3.0/Drivers/STM32G0xx_HAL_Driver/Inc; C:/Users/TANG/STM32Cube/Repository/STM32Cube_FW_G0_V1.3.0/Drivers/STM32G0xx_HAL_Driver/Inc/Legacy; C:/Users/TANG/STM32Cube/Repository/STM32Cube_FW_G0_V1.3.0/Drivers/CMSIS/Device/ST/STM32G0xx/Include; C:/Users/TANG/STM32Cube/Repository/STM32Cube_FW_G0_V1.3.0/Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32g031xx.s
  group Application/User/Core
    ../Core/Src/: bootloader.c main.c gpio.c crc.c usart.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Drivers/STM32G0xx_HAL_Driver
    C:/Users/TANG/STM32Cube/Repository/STM32Cube_FW_G0_V1.3.0/Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_gpio.c stm32g0xx_hal_crc.c stm32g0xx_hal_crc_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group Updata_Driver
    ../Core/Src/: common.c flash_if.c menu.c ymodem.c
  group Readme
    ../: Readme.txt
target LAB_MANUAL_LESSON_3_Ymodem (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G031K8Tx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.2.0
  cpu: as above
  output: LAB_MANUAL_LESSON_3_IAP +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32G031xx,USE_HAL_DRIVER,STM32G031xx
  c include: ../Core/Inc;C:/Users/TANG/STM32Cube/Repository/STM32Cube_FW_G0_V1.3.0/Drivers/STM32G0xx_HAL_Driver/Inc;C:/Users/TANG/STM32Cube/Repository/STM32Cube_FW_G0_V1.3.0/Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;C:/Users/TANG/STM32Cube/Repository/STM32Cube_FW_G0_V1.3.0/Drivers/CMSIS/Device/ST/STM32G0xx/Include;C:/Users/TANG/STM32Cube/Repository/STM32Cube_FW_G0_V1.3.0/Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
software components: CMSIS:CORE 4.3.0
